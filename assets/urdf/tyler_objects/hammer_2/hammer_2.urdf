Commit message: Update hammer_2 to match real world mass and CoM better

File: assets/urdf/tyler_objects/hammer_2/hammer_2.urdf (robot description, URDF)
Before this commit: robot model.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 0.066 -> 0.253
